## boards/catie/z_iaq/board.yml
```yaml
board:
  name: z_iaq
  full_name: Z_IAQ
  vendor: catie
  socs:
    - name: nrf52832
```
